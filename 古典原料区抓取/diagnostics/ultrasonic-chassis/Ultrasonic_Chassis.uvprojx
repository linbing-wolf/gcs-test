# Keil uVision project Ultrasonic_Chassis.uvprojx, settings and files
target UltrasonicChassis (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: ultrasonic_chassis +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,CHASSIS_OBSTACLE_TEST
  c include: ..\..\vendor\stm32\CORE;..\..\vendor\stm32\SYSTEM\delay;..\..\vendor\stm32\SYSTEM\sys;..\..\vendor\stm32\SYSTEM\usart;..\..\vendor\stm32\USER;..\..\vendor\stm32\FWLIB\inc;..\..\vendor\stm32\can_ZDT;..\..\vendor\stm32\Hardware;..\..\vendor\stm32\ckp;..\..\vendor\stm32\SYSTEM;..\..\vendor\stm32\imu;..\..\vendor\stm32\LED;..\..\vendor\stm32\OLED;..\..\vendor\stm32\lanya;..\..\src;..\..\lookup
  asm define: CHASSIS_OBSTACLE_TEST
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\keil\navigation.sct
  group CORE
    ../../vendor/stm32/CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../../vendor/stm32/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../../vendor/stm32/SYSTEM/delay/: delay.c
    ../../vendor/stm32/SYSTEM/sys/: sys.c
    ../../vendor/stm32/SYSTEM/usart/: usart.c
    ../../vendor/stm32/SYSTEM/: Serial.c Serial.h
  group can_ZDT
    ../../vendor/stm32/can_ZDT/: board.c board.h can.c can.h Emm_V5.c Emm_V5.h fifo.c fifo.h yyb_move.c yyb_move.h
    ../../vendor/stm32/Hardware/: pid.h
  group Hardware
    ../../vendor/stm32/Hardware/: PWM.c PWM.h servo.c servo.h swith.c swith.h
    ../../vendor/stm32/USER/: exti.c exti.h
  group LED
    ../../vendor/stm32/LED/: LED.c LED.h
  group ckp
    ../../src/: hmi_status.c
    ../../vendor/stm32/ckp/: uart6_ckp.h
  group imu
    ../../vendor/stm32/imu/: imu.c imu.h REG.h wit_c_sdk.c wit_c_sdk.h timer.c timer.h
  group OLED
    ../../vendor/stm32/OLED/: OLED.c OLED.h OLED_Font.h time_OLED.c time_OLED.h
  group lanya
    ../../vendor/stm32/lanya/: usart5.c usart5.h
  group USER
    ../../src/: main_table_nav.c debug_radio.c start_scan.c
    ../../vendor/stm32/USER/: stm32f4xx_it.c system_stm32f4xx.c
  group Table navigation
    ../../src/: navigation.c road_map.c motion.c heading_sensor.c heading_control.c structure.h navigation.h road_map.h motion.h
    ../../lookup/: route_table.c route_table.h table_data.h
  group ArmControl
    ../../src/: arm_control.c arm_control.h arm_config.h
  group StationControl
    ../../src/: station_job.c vision_link.c station_job.h station_config.h vision_link.h
  group Dual ultrasonic and software UART
    ../ultrasonic-dual-wireless/: main.c
